Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFastener (703)
Name | Length (mm) = Actual length1 (mm) | Edge/Around | Cross section area1 (m2) | Root face thickness1 (mm) | Size1 (mm) | Actual length2 (mm) | Size2 (mm)
8 x Weld | 74 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
2 x Weld | 47.2 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
2 x Weld | 100 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
2 x Weld | 183 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
8 x Weld | 45.5 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
8 x Weld | 78.8 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 134 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
10 x Weld | 60 | Around | 0 | 0 | 5 | 0 | 0
2 x Weld | 47.2 | Edge | 0 | 2 | 5 | 0 | 5 | Tekla Weld Below Line - Type2: W10
2 x Weld | 183 | Edge | 0 | 2 | 5 | 0 | 5 | Tekla Weld Below Line - Type2: W10
2 x Weld | 100 | Edge | 0 | 2 | 5 | 0 | 5 | Tekla Weld Below Line - Type2: W10
8 x Weld | 31.2 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 159 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
2 x Weld | 184.4 | Around | 0 | 0 | 4 | 0 | 0

# IfcMechanicalFastener: Bolt assembly (190)
In: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Site
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Material | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Bolt hole diameter (mm) | Bolt standard | Bolt Name
3 x Bolt assembly | 12 | 45 | 8.8 | 2 | 125 | ALÁTÉT A M12 / DIN | 2 | 934 | HL. ANYA B M12 / DIN | 14 | 931 | HLF. CSAVAR B M12X45 / DIN
51 x Bolt assembly | 12 | 50 | 8.8 | 4 | 125 | ALÁTÉT A M12 / DIN | 2 | 934 | HL. ANYA B M12 / DIN | 14 | 931 | HLF. CSAVAR B M12X50 / DIN
8 x Bolt assembly | 16 | 60 | 8.8 | 2 | 125 | ALÁTÉT A M16 / DIN | 1 | 934 | HL. ANYA B M16 / DIN | 18 | 931 | HLF. CSAVAR B M16X60 / DIN
4 x Bolt assembly | 12 | 40 | 5.8 | 2 | HILTI_ | HILTI M12 | 2 | HILTI | HILTI M12 | 14 | HILTI | HILTI HAS M12X160/28
4 x Bolt assembly | 20 | 55 | 8.8 | 4 | 125 | ALÁTÉT A M20 / DIN | 4 | 934 | HL. ANYA B M20 / DIN | 22 | 931 | HLF. CSAVAR B M20X55 / DIN
4 x Bolt assembly | 16 | 50 | 8.8 | 4 | 125 | ALÁTÉT A M16 / DIN | 4 | 934 | HL. ANYA B M16 / DIN | 18 | 931 | HLF. CSAVAR B M16X50 / DIN
52 x Bolt assembly | 12 | 20 | 8.8 | 2 | 125 | ALÁTÉT A M12 / DIN | 2 | 934 | HL. ANYA B M12 / DIN | 14 | 933 | HLF. TM. CSAVAR B M12X20 / DI
20 x Bolt assembly | 12 | 18 | 8.8 | 4 | 125 | ALÁTÉT A M12 / DIN | 4 | 934 | HL. ANYA B M12 / DIN | 14 | 933 | HLF. TM. CSAVAR B M12X18 / DI
20 x Bolt assembly | 12 | 22 | 8.8 | 2 | 125 | ALÁTÉT A M12 / DIN | 2 | 934 | HL. ANYA B M12 / DIN | 14 | 933 | HLF. TM. CSAVAR B M12X22 / DI
16 x Bolt assembly | 16 | 50 | 5.8 | 2 | HILTI_ | HILTI M16 | 2 | HILTI | HILTI M16 | 19 | HILTI | HILTI HAS M16X190/38
8 x Bolt assembly | 16 | 60 | 8.8 | 1 | 125 | ALÁTÉT A M16 / DIN | 1 | 934 | HL. ANYA B M16 / DIN | 18 | 931 | HLF. CSAVAR B M16X60 / DIN

# IfcMember: RHS50/3 (4)
In: Undefined
Description: RHS50/3; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +10.033; Top elevation: +11.152; Class: 5
Tekla Quantity - Weight: 7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.4 m2; Net surface area: 0.3 m2; Height: 50 mm; Width: 50 mm; Length: 1601.6 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00053866 m2
Name | Phase | Reference | Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
Merevítés | 10 | pa/54 | 1601.6 | 0.319644 | 0.320921 | 0.000897544 | 0.000903304 | 7.04572 | 7.09094
Merevítés | 10 | pa/54 | 1601.56 | 0.319635 | 0.320912 | 0.000897519 | 0.000903279 | 7.04552 | 7.09074
Merevítés | 1 | DUMMY/68 | 1601.6 | 0.319644 | 0.320921 | 0.000897544 | 0.000903304 | 7.04572 | 7.09094
Merevítés | 1 | DUMMY/68 | 1601.56 | 0.319635 | 0.320912 | 0.000897519 | 0.000903279 | 7.04552 | 7.09074
