Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: NemethLaszlo_beep.ifc
Time: 2017-04-12T12:52:46
Author: MELINDA-PC\Melinda
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla structures 21.1 Service Release 2, IFC Export Version: 4.0.0.0 Nov 17 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 200*300 (8)
In: Undefined
Description: 200*300; Material: CONCRETE/C20/25
Tekla Common - Phase: 99; Class: 8
Tekla Quantity - Area per tons: 7.2 m2; Height: 200 mm; Width: 300 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Betonträger | +11.150 | +11.350 | 420.5 | 0.2 | 0.9 | 3 | 2920 | Concrete/5 | 3.04 | 0.1752 | 420.48
2 x Betonträger | +12.050 | +12.250 | 744.5 | 0.3 | 1.6 | 5.3 | 5170 | Concrete/3 | 5.29 | 0.3102 | 744.48
2 x Betonträger | +11.150 | +11.350 | 420.5 | 0.2 | 0.9 | 3 | 2920 | DUMMY/40 | 3.04 | 0.1752 | 420.48
2 x Betonträger | +12.050 | +12.250 | 744.5 | 0.3 | 1.6 | 5.3 | 5170 | DUMMY/38 | 5.29 | 0.3102 | 744.48

# IfcBeam: 300*200 (12)
In: Undefined
Description: 300*200; Material: CONCRETE/C20/25
Tekla Common - Phase: 99; Class: 8
Tekla Quantity - Volume: 0.1 m3; Gross footprint area: 0.1 m2; Height: 300 mm; Width: 200 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Betonträger | +10.430 | +12.050 | 233.3 | 7.5 | 1.7 | 1620 | Concrete/7 | 1620 | 1.74 | 0.0972002 | 233.281
2 x Betonträger | +10.434 | +11.350 | 132 | 7.9 | 1 | 916.3 | Concrete/6 | 916.331 | 1.03633 | 0.0549798 | 131.952
2 x Betonträger | +10.430 | +12.250 | 262.1 | 7.5 | 1.9 | 1820 | Concrete/4 | 1820 | 1.94 | 0.1092 | 262.081
2 x Betonträger | +10.430 | +12.050 | 233.3 | 7.5 | 1.7 | 1620 | DUMMY/42 | 1620 | 1.74 | 0.0972002 | 233.281
2 x Betonträger | +10.434 | +11.350 | 132 | 7.9 | 1 | 916.3 | DUMMY/41 | 916.331 | 1.03633 | 0.0549798 | 131.952
2 x Betonträger | +10.430 | +12.250 | 262.1 | 7.5 | 1.9 | 1820 | DUMMY/39 | 1820 | 1.94 | 0.1092 | 262.081

# IfcBeam: 450*300 (6)
In: Undefined
Description: 450*300; Material: CONCRETE/C20/25
Tekla Common - Bottom elevation: +9.980; Top elevation: +10.430; Phase: 99; Class: 8
Tekla Quantity - Area per tons: 4.7 m2; Height: 450 mm; Width: 300 mm
Pset_BeamCommon - LoadBearing: yes
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Betonträger | 2507.8 | 1 | 2.3 | 11.9 | 7740 | Concrete/1 | 11.88 | 1.0449 | 2507.76
Betonträger | 7251.1 | 3 | 6.7 | 33.8 | 22380 | Concrete/2 | 33.84 | 3.0213 | 7251.12
2 x Betonträger | 2507.8 | 1 | 2.3 | 11.9 | 7740 | DUMMY/43 | 11.88 | 1.0449 | 2507.76
Betonträger | 7251.1 | 3 | 6.7 | 33.8 | 22380 | DUMMY/44 | 33.84 | 3.0213 | 7251.12

# IfcBeam: D16 (4)
In: Undefined
Description: D16; Material: STEEL/S355JR
Tekla Common - Phase: 1; Class: 6
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.5 m2; Net surface area: 0.3 m2; Height: 16 mm; Width: 16 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Merevítés | +10.965 | +11.338 | 9.6 | 6726 | DUMMY/64 | 6725.99 | 0.329824 | 0.00121753 | 9.55764
2 x Merevítés | +10.476 | +10.847 | 9.5 | 6715.5 | DUMMY/63 | 6715.53 | 0.329312 | 0.00121564 | 9.54279

# IfcBeam: EC200-2.5-30-80--7 (6)
In: Undefined
Description: EC200-2.5-30-80--7; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +11.456; Top elevation: +11.656; Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 102.6 m2; Net surface area: 6 m2; Height: 200 mm; Width: 80 mm
Pset_BeamCommon - LoadBearing: yes
Name | Phase | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Szelemen | 11 | 58.2 | 7265 | ps/3 | 5.97204 | 0.00741708 | 58.2241
Szelemen | 11 | 57.8 | 7190 | ps/1 | 5.92911 | 0.00736389 | 57.8066
Szelemen | 11 | 58.2 | 7265 | ps/2 | 5.97204 | 0.00741708 | 58.2241
Szelemen | 1 | 58.2 | 7265 | DUMMY/6 | 5.97204 | 0.00741708 | 58.2241
Szelemen | 1 | 57.8 | 7190 | DUMMY/4 | 5.92911 | 0.00736389 | 57.8066
Szelemen | 1 | 58.2 | 7265 | DUMMY/5 | 5.97204 | 0.00741708 | 58.2241

# IfcBeam: EC200-2.5-30-80-7 (6)
In: Undefined
Description: EC200-2.5-30-80-7; Material: STEEL/S355JR
Tekla Common - Bottom elevation: +10.554; Top elevation: +10.764; Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 102.6 m2; Net surface area: 6 m2; Height: 209.7 mm; Width: 83.1 mm
Pset_BeamCommon - LoadBearing: yes
Name | Phase | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Szelemen | 11 | 58.3 | 7265 | ps/6 | 5.98096 | 0.00742823 | 58.3116
Szelemen | 11 | 57.9 | 7190 | ps/4 | 5.93795 | 0.00737493 | 57.8932
Szelemen | 11 | 58.3 | 7265 | ps/5 | 5.98096 | 0.00742823 | 58.3116
Szelemen | 1 | 58.3 | 7265 | DUMMY/9 | 5.98096 | 0.00742823 | 58.3116
Szelemen | 1 | 57.9 | 7190 | DUMMY/7 | 5.93795 | 0.00737493 | 57.8932
Szelemen | 1 | 58.3 | 7265 | DUMMY/8 | 5.98096 | 0.00742823 | 58.3116

# IfcBeam: PL500/550 (2)
In: Undefined
Description: PL500/550; Material: CONCRETE/C20/25
Tekla Common - Bottom elevation: +9.450; Top elevation: +9.950; Phase: 99; Class: 1
Tekla Quantity - Weight: 14770.8 kg; Volume: 6.2 m3; Gross footprint area: 12.3 m2; Area per tons: 3.2 m2; Net surface area: 47.5 m2; Height: 550 mm; Width: 500 mm; Length: 22380 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 22380 mm; OuterSurfaceArea: 47.548 m2; NetVolume: 6.1545 m3; NetWeight: 14770.8 kg
Name | Reference
VASBETON | VB/1
VASBETON | DUMMY/1

# IfcBeam: RHS100/3 (21)
In: Undefined
Description: RHS100/3; Material: STEEL/S235JR
Tekla Common - Class: 5
Tekla Quantity - Volume: 0 m3; Area per tons: 43.8 m2; Net surface area: 2.8 m2; Height: 100 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Gross footprint area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Merevítés | +10.694 | +10.806 | 10 | 64.2 | 0 | 7037.5 | pa/16 | 7037.5 | 2.81414 | 0.00818205 | 64.2291
Merevítés | +10.694 | +10.806 | 10 | 63.3 | 0 | 6937.5 | pa/49 | 6937.5 | 2.77414 | 0.00806565 | 63.3154
2 x Merevítés | +10.987 | +11.098 | 10 | 64.2 | 0 | 7037.5 | pa/16 | 7037.5 | 2.81414 | 0.00818205 | 64.2291
Merevítés | +10.987 | +11.098 | 10 | 63.6 | 0 | 6967.2 | pa/15 | 6967.2 | 2.78602 | 0.00810022 | 63.5867
2 x Merevítés | +10.403 | +10.503 | 10 | 63.5 | 0.7 | 6958 | pa/53 | 6957.95 | 2.78232 | 0.00808945 | 63.5022
Merevítés | +10.403 | +10.503 | 10 | 63.2 | 0.7 | 6927.5 | pa/51 | 6927.5 | 2.77014 | 0.00805401 | 63.224
2 x Merevítés | +11.287 | +11.387 | 10 | 63.3 | 0.7 | 6938.3 | pa/50 | 6938.25 | 2.77444 | 0.00806652 | 63.3222
Merevítés | +11.287 | +11.387 | 10 | 63.3 | 0.7 | 6937.5 | pa/49 | 6937.5 | 2.77414 | 0.00806565 | 63.3154
2 x Merevítés | +10.403 | +10.503 | 1 | 63.5 | 0.7 | 6958 | DUMMY/62 | 6957.95 | 2.78232 | 0.00808945 | 63.5022
2 x Merevítés | +11.287 | +11.387 | 1 | 63.3 | 0.7 | 6938.3 | DUMMY/61 | 6938.25 | 2.77444 | 0.00806652 | 63.3222
2 x Merevítés | +10.841 | +10.952 | 1 | 64.2 | 0 | 7038.1 | DUMMY/60 | 7038.1 | 2.81438 | 0.00818275 | 64.2346
Merevítés | +10.403 | +10.503 | 1 | 63.2 | 0.7 | 6927.5 | DUMMY/59 | 6927.5 | 2.77014 | 0.00805401 | 63.224
Merevítés | +11.287 | +11.387 | 1 | 63.3 | 0.7 | 6937.5 | DUMMY/58 | 6937.5 | 2.77414 | 0.00806565 | 63.3154
Merevítés | +10.841 | +10.952 | 1 | 63.6 | 0 | 6967.8 | DUMMY/57 | 6967.8 | 2.78626 | 0.00810092 | 63.5922

# IfcBeam: RHS50/3 (6)
In: Undefined
Description: RHS50/3; Material: STEEL/S235JR
Tekla Common - Phase: 10; Class: 6
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.3 m2; Net surface area: 0.8 m2; Height: 50 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Merevítés | +10.459 | +10.764 | 16.8 | 3808.3 | pa/62 | 3808.34 | 0.760141 | 0.0021383 | 16.7857
2 x Merevítés | +10.743 | +11.057 | 17 | 3849.2 | pa/52 | 3849.22 | 0.768315 | 0.00216136 | 16.9667
2 x Merevítés | +11.036 | +11.351 | 17 | 3847.7 | pa/48 | 3847.71 | 0.768014 | 0.00216051 | 16.96

# IfcBeam: Z200/2.0 (10)
In: Undefined
Description: Z200/2.0; Material: STEEL/S355JR
Tekla Common - Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 128.1 m2; Net surface area: 6.7 m2; Height: 200 mm; Width: 138 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Szelemen | +11.302 | +11.517 | 11 | 51.8 | 8740 | ps/9 | 6.64042 | 0.00660394 | 51.841
Szelemen | +11.151 | +11.367 | 11 | 51.8 | 8740 | ps/9 | 6.64042 | 0.00660394 | 51.841
Szelemen | +11.001 | +11.216 | 11 | 51.8 | 8740 | ps/9 | 6.64042 | 0.00660394 | 51.841
Szelemen | +10.851 | +11.066 | 11 | 51.8 | 8740 | ps/9 | 6.64042 | 0.00660394 | 51.841
Szelemen | +10.700 | +10.916 | 11 | 51.8 | 8740 | ps/9 | 6.64042 | 0.00660394 | 51.841
Szelemen | +11.302 | +11.517 | 1 | 51.2 | 8640 | DUMMY/71 | 6.56446 | 0.00652838 | 51.2478
Szelemen | +11.151 | +11.367 | 1 | 51.2 | 8640 | DUMMY/71 | 6.56446 | 0.00652838 | 51.2478
Szelemen | +11.001 | +11.216 | 1 | 51.2 | 8640 | DUMMY/71 | 6.56446 | 0.00652838 | 51.2478
Szelemen | +10.851 | +11.066 | 1 | 51.2 | 8640 | DUMMY/71 | 6.56446 | 0.00652838 | 51.2478
Szelemen | +10.700 | +10.916 | 1 | 51.2 | 8640 | DUMMY/71 | 6.56446 | 0.00652838 | 51.2478

# IfcBeam: Z200/2.5 (20)
In: Undefined
Description: Z200/2.5; Material: STEEL/S355JR
Tekla Common - Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 102.6 m2; Height: 200 mm; Width: 137.5 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Szelemen | +11.299 | +11.514 | 11 | 65.1 | 6.7 | 8760 | ps/8 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +11.148 | +11.363 | 11 | 65.1 | 6.7 | 8760 | ps/8 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +10.998 | +11.213 | 11 | 65.1 | 6.7 | 8760 | ps/8 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +10.847 | +11.063 | 11 | 65.1 | 6.7 | 8760 | ps/8 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +10.697 | +10.912 | 11 | 65.1 | 6.7 | 8760 | ps/8 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +11.299 | +11.514 | 11 | 65.1 | 6.7 | 8760 | ps/7 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +11.148 | +11.363 | 11 | 65.1 | 6.7 | 8760 | ps/7 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +10.998 | +11.213 | 11 | 65.1 | 6.7 | 8760 | ps/7 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +10.847 | +11.063 | 11 | 65.1 | 6.7 | 8760 | ps/7 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +10.697 | +10.912 | 11 | 65.1 | 6.7 | 8760 | ps/7 | 6.67526 | 0.00828696 | 65.0526
Szelemen | +11.299 | +11.514 | 1 | 59.3 | 6.1 | 7990 | DUMMY/11 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +11.148 | +11.363 | 1 | 59.3 | 6.1 | 7990 | DUMMY/11 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +10.998 | +11.213 | 1 | 59.3 | 6.1 | 7990 | DUMMY/11 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +10.847 | +11.063 | 1 | 59.3 | 6.1 | 7990 | DUMMY/11 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +10.697 | +10.912 | 1 | 59.3 | 6.1 | 7990 | DUMMY/11 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +11.299 | +11.514 | 1 | 59.3 | 6.1 | 7990 | DUMMY/10 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +11.148 | +11.363 | 1 | 59.3 | 6.1 | 7990 | DUMMY/10 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +10.998 | +11.213 | 1 | 59.3 | 6.1 | 7990 | DUMMY/10 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +10.847 | +11.063 | 1 | 59.3 | 6.1 | 7990 | DUMMY/10 | 6.08867 | 0.00755854 | 59.3345
Szelemen | +10.697 | +10.912 | 1 | 59.3 | 6.1 | 7990 | DUMMY/10 | 6.08867 | 0.00755854 | 59.3345

# IfcColumn: HEA120 (4)
In: Undefined
Description: HEA120; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +9.962; Top elevation: +11.435; Class: 2
Tekla Quantity - Weight: 29.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 33.6 m2; Net surface area: 1 m2; Height: 114 mm; Width: 120 mm; Length: 1472.6 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 1472.58 mm; OuterSurfaceArea: 0.982213 m2; NetVolume: 0.00353206 m3; NetWeight: 27.7267 kg
Name | Phase | Reference
2 x keretállás | 10 | pa/28
2 x keretállás | 1 | DUMMY/37

# IfcColumn: HEA200 (4)
In: Undefined
Description: HEA200; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +7.112; Top elevation: +10.556; Class: 2
Tekla Quantity - Weight: 145.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 27 m2; Net surface area: 4 m2; Height: 190 mm; Width: 200 mm; Length: 3443.8 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 3443.82 mm; OuterSurfaceArea: 3.92595 m2; NetVolume: 0.0175211 m3; NetWeight: 137.541 kg
Name | Phase | Reference
2 x keretállás | 10 | pa/1
2 x keretállás | 1 | DUMMY/2

# IfcColumn: HEB120 (4)
In: Undefined
Description: HEB120; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +9.962; Top elevation: +11.435; Class: 2
Tekla Quantity - Weight: 39.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.7 m2; Net surface area: 1 m2; Height: 120 mm; Width: 120 mm; Length: 1472.6 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 1472.58 mm; OuterSurfaceArea: 1.01019 m2; NetVolume: 0.00480151 m3; NetWeight: 37.6918 kg
Name | Phase | Reference
2 x keretállás | 10 | pa/2
2 x keretállás | 1 | DUMMY/3

# IfcColumn: IPE200 (4)
In: Undefined
Description: IPE200; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +7.112; Top elevation: +10.557; Class: 2
Tekla Quantity - Weight: 77.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.3 m2; Net surface area: 2.7 m2; Height: 200 mm; Width: 100 mm; Length: 3445 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 3445.04 mm; OuterSurfaceArea: 2.64579 m2; NetVolume: 0.00935359 m3; NetWeight: 73.4257 kg
Name | Phase | Reference
2 x keretállás | 10 | pa/3
2 x keretállás | 1 | DUMMY/12

# IfcDiscreteAccessory: Blech (4)
In: Undefined
Description: BL6*78; Material: STEEL/S235JR
Tekla Common - Phase: 10; Class: 1
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 50 m2; Net surface area: 0 m2; Height: 78.3 mm; Width: 6 mm; Length: 190.1 mm
Pset_PlateCommon - LoadBearing: yes; Reference: pa/66
BaseQuantities - NetArea: 0.0175291 m2; GrossArea: 0.0148882 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000446646 m3; GrossVolume: 0.0000446646 m3
Name | Bottom elevation | Top elevation
2 x Blech | +10.224 | +10.342
2 x Blech | +10.266 | +10.384

# IfcDiscreteAccessory: CLEAT (40)
In: Undefined
Description: L60/4; Material: STEEL/S235JR
Tekla Common - Class: 99
Tekla Quantity - Weight: 0.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 67.3 m2; Net surface area: 0 m2; Height: 60 mm; Width: 60 mm; Length: 185 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 0.045328 m2; GrossArea: 0.045328 m2; CrossSectionArea: 0.000472447 m2; NetVolume: 0.00008584 m3; GrossVolume: 0.00008584 m3
Name | Bottom elevation | Top elevation | Phase | Reference
4 x CLEAT | +11.298 | +11.489 | 10 | pa/57
4 x CLEAT | +11.147 | +11.338 | 10 | pa/57
4 x CLEAT | +10.997 | +11.188 | 10 | pa/57
4 x CLEAT | +10.847 | +11.037 | 10 | pa/57
4 x CLEAT | +10.696 | +10.887 | 10 | pa/57
4 x CLEAT | +11.298 | +11.489 | 1 | DUMMY/72
4 x CLEAT | +11.147 | +11.338 | 1 | DUMMY/72
4 x CLEAT | +10.997 | +11.188 | 1 | DUMMY/72
4 x CLEAT | +10.847 | +11.037 | 1 | DUMMY/72
4 x CLEAT | +10.696 | +10.887 | 1 | DUMMY/72

# IfcDiscreteAccessory: DIN1480_Feszítoanya (4)
In: Undefined
Description: PD42*13; Material: STEEL/S235JRG2
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.9 m2; Net surface area: 0 m2; Height: 42 mm; Width: 42 mm; Length: 170 mm
Pset_PlateCommon - LoadBearing: yes; Reference: DUMMY/33
BaseQuantities - NetArea: 0.0231774 m2; GrossArea: 0.0238136 m2; CrossSectionArea: 0.001131 m2; NetVolume: 0.000123318 m3; GrossVolume: 0.00019227 m3
Name | Bottom elevation | Top elevation
2 x DIN1480_Feszítoanya | +10.946 | +10.997
2 x DIN1480_Feszítoanya | +10.815 | +10.866

# IfcDiscreteAccessory: Merevítés (8)
In: Undefined
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Material | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x Merevítés | PL10/150 | STEEL/S235JR | +9.950 | +9.960 | 10 | 5 | 2 | 28.7 | 0.1 | 150 | 10 | 170 | pa/6 | 0.0573985 | 0.0573985 | 0.0015 | 0.000254993 | 0.000254993
2 x Merevítés | PL10/150 | STEEL/S235JR | +9.950 | +9.960 | 1 | 5 | 2 | 28.7 | 0.1 | 150 | 10 | 170 | DUMMY/28 | 0.0573985 | 0.0573985 | 0.0015 | 0.000254993 | 0.000254993
2 x Merevítés | D16 | STEEL/S355JR | +10.834 | +10.902 | 1 | 6 | 1.5 | 34.7 | 0 | 16 | 16 | 1000 | DUMMY/65 | 0.0493455 | 0.0560245 | 0.000181019 | 0.000181019 | 0.000205702
2 x Merevítés | D16 | STEEL/S355JR | +10.909 | +10.978 | 1 | 6 | 1.5 | 34.7 | 0 | 16 | 16 | 1000 | DUMMY/65 | 0.0493455 | 0.0560314 | 0.000181019 | 0.000181019 | 0.000205727

# IfcDiscreteAccessory: PLATE (341)
In: Undefined
Material: STEEL/S235JR
Tekla Common - Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLATE | PL3*21 | +11.325 | +11.351 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL3*21 | +11.296 | +11.323 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL8*90 | +11.308 | +11.337 | 10 | 0.9 | 36.2 | 0 | 90 | 8 | 163 | pa/18 | 0.033388 | 0.01467 | 0.000064 | 0.00011736
PLATE | PL8*152 | +11.308 | +11.335 | 10 | 5.2 | 34 | 0.2 | 152.1 | 8 | 570.7 | pa/37 | 0.177131 | 0.0868051 | 0.000064 | 0.000664497
2 x PLATE | PL3*21 | +10.487 | +10.513 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL3*21 | +10.458 | +10.485 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL8*90 | +10.473 | +10.501 | 10 | 0.9 | 36.2 | 0 | 90 | 8 | 163 | pa/18 | 0.033388 | 0.01467 | 0.000064 | 0.00011736
2 x PLATE | PL8*141 | +10.461 | +10.486 | 10 | 0.9 | 36 | 0 | 140.8 | 8 | 134.7 | pa/41 | 0.0326858 | 0.0189659 | 0.000064 | 0.000115541
2 x PLATE | PL3*21 | +10.739 | +10.765 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL3*21 | +10.710 | +10.736 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL8*90 | +10.722 | +10.750 | 10 | 0.9 | 36.2 | 0 | 90 | 8 | 163 | pa/18 | 0.033388 | 0.01467 | 0.000064 | 0.00011736
PLATE | PL8*153 | +10.721 | +10.748 | 10 | 5.2 | 34 | 0.2 | 152.7 | 8 | 561.1 | pa/36 | 0.174918 | 0.0857094 | 0.000064 | 0.000656186
2 x PLATE | PL3*21 | +10.772 | +10.798 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL3*21 | +10.743 | +10.769 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL8*90 | +10.758 | +10.786 | 10 | 0.9 | 36.2 | 0 | 90 | 8 | 163 | pa/18 | 0.033388 | 0.01467 | 0.000064 | 0.00011736
2 x PLATE | PL8*141 | +10.746 | +10.770 | 10 | 0.9 | 36 | 0 | 141.4 | 8 | 136.6 | pa/39 | 0.0330899 | 0.0193068 | 0.000064 | 0.000117051
2 x PLATE | PL3*21 | +11.031 | +11.057 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL3*21 | +11.002 | +11.028 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL8*90 | +11.014 | +11.042 | 10 | 0.9 | 36.2 | 0 | 90 | 8 | 163 | pa/18 | 0.033388 | 0.01467 | 0.000064 | 0.00011736
PLATE | PL8*153 | +11.014 | +11.041 | 10 | 5 | 34 | 0.2 | 152.6 | 8 | 548.7 | pa/19 | 0.170705 | 0.0837487 | 0.000064 | 0.000640158
2 x PLATE | PL3*21 | +11.064 | +11.090 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL3*21 | +11.036 | +11.062 | 10 | 0 | 102.2 | 0 | 21 | 3 | 50 | pa/64 | 0.002526 | 0.00105 | 0.000009 | 0.00000315
2 x PLATE | PL8*90 | +11.050 | +11.078 | 10 | 0.9 | 36.2 | 0 | 90 | 8 | 163 | pa/18 | 0.033388 | 0.01467 | 0.000064 | 0.00011736
2 x PLATE | PL8*142 | +11.038 | +11.063 | 10 | 0.9 | 36 | 0 | 141.6 | 8 | 137.2 | pa/38 | 0.0332292 | 0.0194242 | 0.000064 | 0.000117571
6 x PLATE | PL3*46 | +10.701 | +10.806 | 10 | 0.1 | 93 | 0 | 46 | 3 | 100 | pa/63 | 0.010076 | 0.0046 | 0.000009 | 0.0000138
6 x PLATE | PL3*46 | +10.694 | +10.799 | 10 | 0.1 | 93 | 0 | 46 | 3 | 100 | pa/63 | 0.010076 | 0.0046 | 0.000009 | 0.0000138
6 x PLATE | PL8*140 | +10.680 | +10.820 | 10 | 1.5 | 35.2 | 0.1 | 140 | 8 | 163 | pa/17 | 0.050488 | 0.02282 | 0.000064 | 0.00018256
2 x PLATE | PL8*65 | +10.658 | +10.840 | 10 | 0.7 | 37.1 | 0 | 65 | 8 | 182.4 | pa/43 | 0.0270588 | 0.011856 | 0.000064 | 0.0000929753
2 x PLATE | PL8*65 | +10.620 | +10.839 | 10 | 0.9 | 36.8 | 0 | 65 | 8 | 219.8 | pa/44 | 0.0325192 | 0.014287 | 0.000064 | 0.000112423
PLATE | PL8*130 | +10.619 | +10.839 | 10 | 1.8 | 34.9 | 0.1 | 130 | 8 | 220.4 | pa/46 | 0.0623198 | 0.028652 | 0.000064 | 0.000227416
PLATE | PL8*100 | +10.620 | +10.839 | 10 | 1.5 | 35.5 | 0 | 100 | 8 | 219.8 | pa/42 | 0.0484652 | 0.02198 | 0.000064 | 0.000173967
6 x PLATE | PL3*46 | +10.993 | +11.098 | 10 | 0.1 | 93 | 0 | 46 | 3 | 100 | pa/63 | 0.010076 | 0.0046 | 0.000009 | 0.0000138
6 x PLATE | PL3*46 | +10.987 | +11.092 | 10 | 0.1 | 93 | 0 | 46 | 3 | 100 | pa/63 | 0.010076 | 0.0046 | 0.000009 | 0.0000138
6 x PLATE | PL8*140 | +10.973 | +11.113 | 10 | 1.5 | 35.2 | 0.1 | 140 | 8 | 163 | pa/17 | 0.050488 | 0.02282 | 0.000064 | 0.00018256
2 x PLATE | PL8*65 | +10.951 | +11.133 | 10 | 0.7 | 37.1 | 0 | 65 | 8 | 182.4 | pa/43 | 0.0270588 | 0.011856 | 0.000064 | 0.0000929753
2 x PLATE | PL8*65 | +10.912 | +11.131 | 10 | 0.9 | 36.8 | 0 | 65 | 8 | 219.8 | pa/44 | 0.0325192 | 0.014287 | 0.000064 | 0.000112423
2 x PLATE | PL8*100 | +10.912 | +11.131 | 10 | 1.5 | 35.5 | 0 | 100 | 8 | 219.8 | pa/42 | 0.0484652 | 0.02198 | 0.000064 | 0.000173967
2 x PLATE | PL8*86 | +10.377 | +10.542 | 10 | 0.9 | 36.3 | 0 | 86 | 8 | 165 | pa/40 | 0.0322491 | 0.01419 | 0.000064 | 0.00011312
4 x PLATE | PL8*120 | +10.398 | +10.542 | 10 | 1.1 | 35.7 | 0 | 120 | 8 | 144 | pa/35 | 0.0386371 | 0.01728 | 0.000064 | 0.00013784
12 x PLATE | PL3*43 | +10.406 | +10.500 | 10 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | pa/47 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL8*110 | +10.398 | +10.508 | 10 | 1.1 | 35.7 | 0 | 110 | 8 | 163 | pa/34 | 0.040228 | 0.01793 | 0.000064 | 0.00014344
6 x PLATE | PL3*43 | +11.341 | +11.384 | 10 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | pa/47 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL3*43 | +11.290 | +11.333 | 10 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | pa/47 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL8*110 | +11.333 | +11.341 | 10 | 1.1 | 35.7 | 0 | 110 | 8 | 163 | pa/33 | 0.040228 | 0.01793 | 0.000064 | 0.00014344
2 x PLATE | PL8*98 | +11.325 | +11.333 | 10 | 0.7 | 36.6 | 0 | 98 | 8 | 115 | pa/31 | 0.0253574 | 0.01127 | 0.000064 | 0.00008836
4 x PLATE | PL8*98 | +11.325 | +11.333 | 10 | 0.7 | 36.6 | 0 | 98 | 8 | 115 | pa/32 | 0.0253574 | 0.01127 | 0.000064 | 0.00008836
2 x PLATE | PL3*18 | +10.034 | +10.068 | 10 | 0 | 104.9 | 0 | 18 | 3 | 44 | pa/45 | 0.00195601 | 0.000792005 | 0.000009 | 0.00000237602
2 x PLATE | PL3*18 | +10.034 | +10.068 | 10 | 0 | 104.9 | 0 | 18 | 3 | 44 | pa/45 | 0.00195601 | 0.000792006 | 0.000009 | 0.00000237602
2 x PLATE | PL8*70 | +9.970 | +10.118 | 10 | 0.7 | 37.3 | 0 | 70 | 8 | 143 | pa/30 | 0.023428 | 0.01001 | 0.000064 | 0.0000800802
4 x PLATE | PL3*18 | +11.117 | +11.151 | 10 | 0 | 104.9 | 0 | 18 | 3 | 44 | pa/45 | 0.001956 | 0.000792 | 0.000009 | 0.000002376
2 x PLATE | PL8*70 | +11.067 | +11.215 | 10 | 0.7 | 37.3 | 0 | 70 | 8 | 143 | pa/30 | 0.023428 | 0.01001 | 0.000064 | 0.00008008
PLATE | PL8*112 | +9.960 | +10.069 | 10 | 0.7 | 37.3 | 0 | 112.2 | 8 | 161.3 | pa/29 | 0.0244397 | 0.0180897 | 0.000064 | 0.0000832094
PLATE | PL8*109 | +9.960 | +10.069 | 10 | 0.7 | 37.3 | 0 | 108.9 | 8 | 166.1 | pa/29 | 0.0244259 | 0.0180897 | 0.000064 | 0.000083157
2 x PLATE | PL8*109 | +11.116 | +11.227 | 10 | 0.7 | 37 | 0 | 108.9 | 8 | 110.9 | pa/24 | 0.021399 | 0.0120804 | 0.000064 | 0.0000736971
2 x PLATE | PL16*120 | +10.495 | +10.735 | 10 | 3.6 | 19.1 | 0.1 | 120 | 16 | 240 | pa/56 | 0.06912 | 0.06912 | 0.00192 | 0.0004608
2 x PLATE | PL16*120 | +10.493 | +10.733 | 10 | 3.6 | 19.1 | 0.1 | 120 | 16 | 240 | pa/56 | 0.06912 | 0.06912 | 0.00192 | 0.0004608
2 x PLATE | PL16*140 | +10.463 | +10.723 | 10 | 4.6 | 18.7 | 0.1 | 140 | 16 | 260 | pa/55 | 0.0856 | 0.0856 | 0.00224 | 0.0005824
2 x PLATE | PL16*140 | +10.465 | +10.725 | 10 | 4.6 | 18.7 | 0.1 | 140 | 16 | 260 | pa/55 | 0.0856 | 0.0856 | 0.00224 | 0.0005824
4 x PLATE | PL10*58 | +11.230 | +11.240 | 10 | 0.4 | 32.4 | 0 | 57.5 | 10 | 98 | pa/12 | 0.0139514 | 0.005635 | 0.0001 | 0.00005491
4 x PLATE | PL10*43 | +10.366 | +10.376 | 10 | 0.7 | 32.7 | 0 | 43.2 | 10 | 183 | pa/11 | 0.0199066 | 0.0079056 | 0.0001 | 0.000077616
4 x PLATE | PL10*57 | +11.189 | +11.199 | 10 | 0.4 | 32.4 | 0 | 56.8 | 10 | 98 | pa/14 | 0.0137894 | 0.0055615 | 0.0001 | 0.000054175
4 x PLATE | PL10*97 | +10.325 | +10.335 | 10 | 1.3 | 29.4 | 0 | 96.8 | 10 | 170 | pa/13 | 0.0373711 | 0.0164475 | 0.0001 | 0.000161235
2 x PLATE | PL10*120 | +11.421 | +11.444 | 10 | 0.9 | 30 | 0 | 120 | 10 | 106.9 | pa/10 | 0.0301943 | 0.0301943 | 0.0012 | 0.000128281
2 x PLATE | PL10*120 | +11.421 | +11.444 | 10 | 0.9 | 30.1 | 0 | 120 | 10 | 101 | pa/8 | 0.0286226 | 0.0286226 | 0.0012 | 0.000121027
2 x PLATE | PL10*200 | +10.533 | +10.565 | 10 | 2.8 | 28.2 | 0.1 | 200 | 10 | 177.4 | pa/9 | 0.0785193 | 0.0785193 | 0.002 | 0.000354854
2 x PLATE | PL12*190 | +7.100 | +7.112 | 10 | 3.4 | 23.9 | 0.1 | 190 | 12 | 188 | pa/22 | 0.080512 | 0.080512 | 0.00228 | 0.00042864
2 x PLATE | PL12*190 | +7.100 | +7.112 | 10 | 3.2 | 23.9 | 0.1 | 190 | 12 | 178 | pa/23 | 0.076472 | 0.076472 | 0.00228 | 0.00040584
2 x PLATE | PL12*190 | +9.950 | +9.962 | 10 | 1.8 | 25.1 | 0 | 190 | 12 | 102 | pa/20 | 0.045768 | 0.045768 | 0.00228 | 0.00023256
2 x PLATE | PL12*190 | +9.950 | +9.962 | 10 | 2 | 24.9 | 0 | 190 | 12 | 108 | pa/21 | 0.048192 | 0.048192 | 0.00228 | 0.00024624
2 x PLATE | PL10*100 | +10.533 | +10.566 | 10 | 1.5 | 29.4 | 0 | 100 | 10 | 187.5 | pa/7 | 0.0432504 | 0.0432504 | 0.001 | 0.000187502
2 x PLATE | PL3*18 | +10.034 | +10.068 | 1 | 0 | 104.9 | 0 | 18 | 3 | 44 | DUMMY/67 | 0.00195601 | 0.000792005 | 0.000009 | 0.00000237602
2 x PLATE | PL3*18 | +10.034 | +10.068 | 1 | 0 | 104.9 | 0 | 18 | 3 | 44 | DUMMY/67 | 0.00195601 | 0.000792006 | 0.000009 | 0.00000237602
2 x PLATE | PL8*70 | +9.970 | +10.118 | 1 | 0.7 | 37.3 | 0 | 70 | 8 | 143 | DUMMY/56 | 0.023428 | 0.01001 | 0.000064 | 0.0000800802
PLATE | PL8*109 | +9.960 | +10.069 | 1 | 0.7 | 37.3 | 0 | 108.9 | 8 | 166.1 | DUMMY/55 | 0.0244259 | 0.0180897 | 0.000064 | 0.000083157
6 x PLATE | PL3*43 | +11.341 | +11.384 | 1 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | DUMMY/66 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL3*43 | +11.290 | +11.333 | 1 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | DUMMY/66 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL8*110 | +11.333 | +11.341 | 1 | 1.1 | 35.7 | 0 | 110 | 8 | 163 | DUMMY/54 | 0.040228 | 0.01793 | 0.000064 | 0.00014344
2 x PLATE | PL8*98 | +11.325 | +11.333 | 1 | 0.7 | 36.6 | 0 | 98 | 8 | 115 | DUMMY/51 | 0.0253574 | 0.01127 | 0.000064 | 0.00008836
4 x PLATE | PL8*98 | +11.325 | +11.333 | 1 | 0.7 | 36.6 | 0 | 98 | 8 | 115 | DUMMY/52 | 0.0253574 | 0.01127 | 0.000064 | 0.00008836
4 x PLATE | PL3*18 | +11.117 | +11.151 | 1 | 0 | 104.9 | 0 | 18 | 3 | 44 | DUMMY/67 | 0.001956 | 0.000792 | 0.000009 | 0.000002376
2 x PLATE | PL8*70 | +11.067 | +11.215 | 1 | 0.7 | 37.3 | 0 | 70 | 8 | 143 | DUMMY/56 | 0.023428 | 0.01001 | 0.000064 | 0.00008008
2 x PLATE | PL8*109 | +11.116 | +11.227 | 1 | 0.7 | 37 | 0 | 108.9 | 8 | 110.9 | DUMMY/47 | 0.021399 | 0.0120804 | 0.000064 | 0.0000736971
PLATE | PL8*112 | +9.960 | +10.069 | 1 | 0.7 | 37.3 | 0 | 112.2 | 8 | 161.3 | DUMMY/55 | 0.0244397 | 0.0180897 | 0.000064 | 0.0000832094
2 x PLATE | PL10*70 | +10.881 | +10.907 | 1 | 0.7 | 33.4 | 0 | 70 | 10 | 160 | DUMMY/27 | 0.0255628 | 0.0112 | 0.0001 | 0.0000974
2 x PLATE | PL10*103 | +10.876 | +10.900 | 1 | 0.7 | 30.8 | 0 | 103.4 | 10 | 113.5 | DUMMY/26 | 0.0214527 | 0.0117329 | 0.0001 | 0.0000887775
2 x PLATE | PL10*70 | +10.905 | +10.930 | 1 | 0.7 | 33.4 | 0 | 70 | 10 | 160 | DUMMY/27 | 0.0255628 | 0.0112 | 0.0001 | 0.0000974
2 x PLATE | PL10*104 | +10.891 | +10.915 | 1 | 0.7 | 30.8 | 0 | 103.4 | 10 | 119.5 | DUMMY/25 | 0.0223575 | 0.012369 | 0.0001 | 0.0000928196
2 x PLATE | PL10*70 | +11.317 | +11.342 | 1 | 0.7 | 33.4 | 0 | 70 | 10 | 160 | DUMMY/27 | 0.0255629 | 0.0112 | 0.0001 | 0.0000974001
2 x PLATE | PL10*104 | +11.312 | +11.334 | 1 | 0.7 | 30.8 | 0 | 103.4 | 10 | 100.3 | DUMMY/24 | 0.0202773 | 0.0103842 | 0.0001 | 0.0000837508
2 x PLATE | PL10*70 | +10.472 | +10.497 | 1 | 0.7 | 33.4 | 0 | 70 | 10 | 160 | DUMMY/27 | 0.0255628 | 0.0112 | 0.0001 | 0.0000974
2 x PLATE | PL10*103 | +10.460 | +10.483 | 1 | 0.7 | 30.8 | 0 | 103.4 | 10 | 103.1 | DUMMY/23 | 0.0207506 | 0.0106656 | 0.0001 | 0.0000858968
2 x PLATE | PL10*120 | +11.421 | +11.444 | 1 | 0.9 | 30 | 0 | 120 | 10 | 106.9 | DUMMY/22 | 0.0301943 | 0.0301943 | 0.0012 | 0.000128281
2 x PLATE | PL10*120 | +11.421 | +11.444 | 1 | 0.9 | 30.1 | 0 | 120 | 10 | 101 | DUMMY/20 | 0.0286226 | 0.0286226 | 0.0012 | 0.000121027
12 x PLATE | PL3*43 | +10.406 | +10.500 | 1 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | DUMMY/66 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL8*110 | +10.398 | +10.508 | 1 | 1.1 | 35.7 | 0 | 110 | 8 | 163 | DUMMY/53 | 0.040228 | 0.01793 | 0.000064 | 0.00014344
2 x PLATE | PL8*86 | +10.377 | +10.542 | 1 | 0.9 | 36.3 | 0 | 86 | 8 | 165 | DUMMY/45 | 0.0322491 | 0.01419 | 0.000064 | 0.00011312
4 x PLATE | PL8*120 | +10.398 | +10.542 | 1 | 1.1 | 35.7 | 0 | 120 | 8 | 144 | DUMMY/46 | 0.0386371 | 0.01728 | 0.000064 | 0.00013784
2 x PLATE | PL10*200 | +10.533 | +10.565 | 1 | 2.8 | 28.2 | 0.1 | 200 | 10 | 177.4 | DUMMY/21 | 0.0785193 | 0.0785193 | 0.002 | 0.000354854
6 x PLATE | PL3*43 | +10.850 | +10.949 | 1 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | DUMMY/66 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL3*43 | +10.844 | +10.943 | 1 | 0.1 | 93.6 | 0 | 43 | 3 | 94 | DUMMY/66 | 0.008906 | 0.004042 | 0.000009 | 0.000012126
6 x PLATE | PL8*110 | +10.841 | +10.951 | 1 | 1.1 | 35.7 | 0 | 110 | 8 | 163 | DUMMY/53 | 0.040228 | 0.01793 | 0.000064 | 0.00014344
2 x PLATE | PL8*65 | +10.804 | +10.987 | 1 | 0.7 | 37.1 | 0 | 65 | 8 | 183 | DUMMY/48 | 0.0271674 | 0.011895 | 0.000064 | 0.00009336
2 x PLATE | PL8*65 | +10.766 | +10.985 | 1 | 0.9 | 36.8 | 0 | 65 | 8 | 220.4 | DUMMY/49 | 0.0326278 | 0.014326 | 0.000064 | 0.000112808
2 x PLATE | PL8*100 | +10.766 | +10.985 | 1 | 1.5 | 35.5 | 0 | 100 | 8 | 220.4 | DUMMY/50 | 0.0486158 | 0.02204 | 0.000064 | 0.00017452
2 x PLATE | PL12*190 | +7.100 | +7.112 | 1 | 3.4 | 23.9 | 0.1 | 190 | 12 | 188 | DUMMY/31 | 0.080512 | 0.080512 | 0.00228 | 0.00042864
2 x PLATE | PL12*190 | +7.100 | +7.112 | 1 | 3.2 | 23.9 | 0.1 | 190 | 12 | 178 | DUMMY/32 | 0.076472 | 0.076472 | 0.00228 | 0.00040584
2 x PLATE | PL16*120 | +10.495 | +10.735 | 1 | 3.6 | 19.1 | 0.1 | 120 | 16 | 240 | DUMMY/70 | 0.06912 | 0.06912 | 0.00192 | 0.0004608
2 x PLATE | PL16*120 | +10.493 | +10.733 | 1 | 3.6 | 19.1 | 0.1 | 120 | 16 | 240 | DUMMY/70 | 0.06912 | 0.06912 | 0.00192 | 0.0004608
2 x PLATE | PL16*140 | +10.463 | +10.723 | 1 | 4.6 | 18.7 | 0.1 | 140 | 16 | 260 | DUMMY/69 | 0.0856 | 0.0856 | 0.00224 | 0.0005824
2 x PLATE | PL16*140 | +10.465 | +10.725 | 1 | 4.6 | 18.7 | 0.1 | 140 | 16 | 260 | DUMMY/69 | 0.0856 | 0.0856 | 0.00224 | 0.0005824
2 x PLATE | PL12*190 | +9.950 | +9.962 | 1 | 1.8 | 25.1 | 0 | 190 | 12 | 102 | DUMMY/29 | 0.045768 | 0.045768 | 0.00228 | 0.00023256
2 x PLATE | PL12*190 | +9.950 | +9.962 | 1 | 2 | 24.9 | 0 | 190 | 12 | 108 | DUMMY/30 | 0.048192 | 0.048192 | 0.00228 | 0.00024624
4 x PLATE | PL10*57 | +11.189 | +11.199 | 1 | 0.4 | 32.4 | 0 | 56.8 | 10 | 98 | DUMMY/18 | 0.0137894 | 0.0055615 | 0.0001 | 0.000054175
4 x PLATE | PL10*58 | +11.230 | +11.240 | 1 | 0.4 | 32.4 | 0 | 57.5 | 10 | 98 | DUMMY/16 | 0.0139514 | 0.005635 | 0.0001 | 0.00005491
4 x PLATE | PL10*97 | +10.325 | +10.335 | 1 | 1.3 | 29.4 | 0 | 96.8 | 10 | 170 | DUMMY/17 | 0.0373711 | 0.0164475 | 0.0001 | 0.000161235
4 x PLATE | PL10*43 | +10.366 | +10.376 | 1 | 0.7 | 32.7 | 0 | 43.2 | 10 | 183 | DUMMY/15 | 0.0199066 | 0.0079056 | 0.0001 | 0.000077616
2 x PLATE | PL10*100 | +10.533 | +10.566 | 1 | 1.5 | 29.4 | 0 | 100 | 10 | 187.5 | DUMMY/19 | 0.0432504 | 0.0432504 | 0.001 | 0.000187502

# IfcDiscreteAccessory: Träger (8)
In: Undefined
Description: PL4/190; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +10.350; Top elevation: +10.686; Class: 3
Tekla Quantity - Weight: 7.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 65.2 m2; Net surface area: 0.5 m2; Height: 190 mm; Width: 4 mm; Length: 1209.5 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - NetArea: 0.4663 m2; GrossArea: 0.4663 m2; CrossSectionArea: 0.00076 m2; NetVolume: 0.000910382 m3; GrossVolume: 0.000910382 m3
Name | Phase | Reference
4 x Träger | 10 | pa/61
4 x Träger | 1 | DUMMY/76

# IfcDiscreteAccessory: Unnamed (4)
In: Undefined
Description: PL10*100; Material: STEEL/S235JR
Tekla Common - Phase: 10; Class: 5
Tekla Quantity - Weight: 1.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.4 m2; Net surface area: 0 m2; Height: 100 mm; Width: 10 mm; Length: 190.1 mm
Pset_PlateCommon - LoadBearing: yes; Reference: pa/65
BaseQuantities - NetArea: 0.0438325 m2; GrossArea: 0.0438325 m2; CrossSectionArea: 0.001 m2; NetVolume: 0.000190148 m3; GrossVolume: 0.000190148 m3
Name | Bottom elevation | Top elevation
2 x Unnamed | +10.216 | +10.342
2 x Unnamed | +10.258 | +10.384

# IfcDiscreteAccessory: keretállás (56)
In: Undefined
Material: STEEL/S235JR
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x keretállás | PL5/60 | +10.543 | +10.729 | 10 | 2 | 0.4 | 56.6 | 0 | 60 | 5 | 185.5 | pa/27 | 0.0242362 | 0.0003 | 0.00005454 | 0.00005454
2 x keretállás | PL5/60 | +10.543 | +10.729 | 10 | 2 | 0.4 | 56.6 | 0 | 60 | 5 | 185.5 | pa/27 | 0.0242357 | 0.0003 | 0.0000545387 | 0.0000545387
4 x keretállás | PL5/120 | +10.579 | +10.729 | 10 | 2 | 0.7 | 54.8 | 0 | 120 | 5 | 150 | pa/25 | 0.0387 | 0.0006 | 0.00009 | 0.00009
4 x keretállás | PL5/120 | +11.481 | +11.631 | 10 | 2 | 0.7 | 54.8 | 0 | 120 | 5 | 150 | pa/25 | 0.0387 | 0.0006 | 0.00009 | 0.00009
2 x keretállás | PL5/60 | +11.436 | +11.631 | 10 | 2 | 0.4 | 56.5 | 0 | 60 | 5 | 194.7 | pa/26 | 0.0254334 | 0.0003 | 0.0000573027 | 0.0000573027
2 x keretállás | PL5/60 | +11.436 | +11.631 | 10 | 2 | 0.4 | 56.5 | 0 | 60 | 5 | 194.7 | pa/26 | 0.0254336 | 0.0003 | 0.0000573032 | 0.0000573032
4 x keretállás | PL4/158 | +9.340 | +10.549 | 10 | 3 | 6 | 65.5 | 0.3 | 158 | 4 | 1209.7 | pa/60 | 0.39007 | 0.000632 | 0.000758402 | 0.000758402
2 x keretállás | IPE200 | +10.517 | +11.431 | 10 | 3 | 131.3 | 34.3 | 4.6 | 200 | 100 | 5870.7 | pa/5 | 4.50871 | 0.00285 | 0.0159631 | 0.0167315
2 x keretállás | IPE240 | +10.477 | +11.430 | 10 | 3 | 180 | 30 | 5.6 | 240 | 120 | 5864.7 | pa/59 | 5.40723 | 0.003909 | 0.0217529 | 0.022925
2 x keretállás | IPE200 | +10.366 | +10.711 | 10 | 3 | 27 | 34.3 | 0.8 | 200 | 100 | 1207.7 | pa/4 | 0.92748 | 0.00285 | 0.00325717 | 0.00344182
2 x keretállás | IPE240 | +10.324 | +10.711 | 10 | 3 | 37.5 | 30 | 1.2 | 240 | 120 | 1222.6 | pa/58 | 1.12728 | 0.003909 | 0.00449158 | 0.00477931
2 x keretállás | PL5/60 | +10.543 | +10.729 | 1 | 2 | 0.4 | 56.6 | 0 | 60 | 5 | 185.5 | DUMMY/36 | 0.0242362 | 0.0003 | 0.00005454 | 0.00005454
2 x keretállás | PL5/60 | +10.543 | +10.729 | 1 | 2 | 0.4 | 56.6 | 0 | 60 | 5 | 185.5 | DUMMY/36 | 0.0242357 | 0.0003 | 0.0000545387 | 0.0000545387
4 x keretállás | PL5/120 | +10.579 | +10.729 | 1 | 2 | 0.7 | 54.8 | 0 | 120 | 5 | 150 | DUMMY/34 | 0.0387 | 0.0006 | 0.00009 | 0.00009
4 x keretállás | PL5/120 | +11.481 | +11.631 | 1 | 2 | 0.7 | 54.8 | 0 | 120 | 5 | 150 | DUMMY/34 | 0.0387 | 0.0006 | 0.00009 | 0.00009
2 x keretállás | PL5/60 | +11.436 | +11.631 | 1 | 2 | 0.4 | 56.5 | 0 | 60 | 5 | 194.7 | DUMMY/35 | 0.0254334 | 0.0003 | 0.0000573027 | 0.0000573027
2 x keretállás | PL5/60 | +11.436 | +11.631 | 1 | 2 | 0.4 | 56.5 | 0 | 60 | 5 | 194.7 | DUMMY/35 | 0.0254336 | 0.0003 | 0.0000573032 | 0.0000573032
4 x keretállás | PL4/158 | +9.340 | +10.549 | 1 | 3 | 6 | 65.5 | 0.3 | 158 | 4 | 1209.7 | DUMMY/75 | 0.39007 | 0.000632 | 0.000758402 | 0.000758402
2 x keretállás | IPE200 | +10.517 | +11.431 | 1 | 3 | 131.3 | 34.3 | 4.6 | 200 | 100 | 5870.7 | DUMMY/14 | 4.50871 | 0.00285 | 0.0159631 | 0.0167315
2 x keretállás | IPE240 | +10.477 | +11.430 | 1 | 3 | 180 | 30 | 5.6 | 240 | 120 | 5864.7 | DUMMY/74 | 5.40723 | 0.003909 | 0.0217529 | 0.022925
2 x keretállás | IPE200 | +10.366 | +10.711 | 1 | 3 | 27 | 34.3 | 0.8 | 200 | 100 | 1207.7 | DUMMY/13 | 0.92748 | 0.00285 | 0.00325717 | 0.00344182
2 x keretállás | IPE240 | +10.324 | +10.711 | 1 | 3 | 37.5 | 30 | 1.2 | 240 | 120 | 1222.6 | DUMMY/73 | 1.12728 | 0.003909 | 0.00449158 | 0.00477931

# IfcElementAssembly (125)
In: Undefined
Name | PredefinedType | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | RIGID_FRAME | 217.1 | +7.100 | +10.887 | D/2(09)> | A/2 | 267.102
Steel Assembly | RIGID_FRAME | 217.1 | +7.100 | +10.887 | E/2(09)> | A/1 | 267.102
Steel Assembly | RIGID_FRAME | 130.2 | +7.100 | +10.887 | C/2(09)> | A/6 | 190
Steel Assembly | RIGID_FRAME | 130.2 | +7.100 | +10.887 | F/2(09)> | A/5 | 190
2 x Steel Assembly | RIGID_FRAME | 18.9 | +11.036 | +11.351 | D-E/2(09)> | A/22 | 90
Steel Assembly | RIGID_FRAME | 71.2 | +11.287 | +11.387 | D-E/2(09)> | A/15 | 256.957
2 x Steel Assembly | RIGID_FRAME | 18.7 | +10.458 | +10.765 | D-E/2(09)> | A/24 | 90
Steel Assembly | RIGID_FRAME | 71.8 | +10.680 | +10.820 | D-E/2(09)> | A/21 | 252.74
2 x Steel Assembly | RIGID_FRAME | 18.9 | +10.743 | +11.057 | D-E/2(09)> | A/23 | 90
Steel Assembly | RIGID_FRAME | 239.2 | +9.950 | +11.631 | D/2(09)> | A/7 | 262.944
Steel Assembly | RIGID_FRAME | 71.9 | +10.973 | +11.113 | D-E/2(09)> | A/19 | 252.644
Steel Assembly | RIGID_FRAME | 239.6 | +9.950 | +11.631 | E/2(09)> | A/8 | 262.944
Steel Assembly | RIGID_FRAME | 67.5 | +10.680 | +10.820 | E-F/2(09)> | A/20 | 100
Steel Assembly | RIGID_FRAME | 174.4 | +9.950 | +11.631 | F/2(09)> | A/9 | 212.5
Steel Assembly | RIGID_FRAME | 67.5 | +10.680 | +10.820 | C-D/2(09)> | A/20 | 100
Steel Assembly | RIGID_FRAME | 174.4 | +9.950 | +11.631 | C/2(09)> | A/10 | 212.5
Steel Assembly | RIGID_FRAME | 67.5 | +10.973 | +11.113 | E-F/2(09)> | A/20 | 100
Steel Assembly | RIGID_FRAME | 67.5 | +10.973 | +11.113 | C-D/2(09)> | A/20 | 100
Steel Assembly | RIGID_FRAME | 66.1 | +10.398 | +10.508 | E-F/2(09)> | A/18 | 100
Steel Assembly | RIGID_FRAME | 66.1 | +10.398 | +10.508 | C-D/2(09)> | A/18 | 100
Steel Assembly | RIGID_FRAME | 65.9 | +10.398 | +10.508 | D-E/2(09)> | A/17 | 100
Steel Assembly | RIGID_FRAME | 65.9 | +11.287 | +11.387 | E-F/2(09)> | A/16 | 110
Steel Assembly | RIGID_FRAME | 65.9 | +11.287 | +11.387 | C-D/2(09)> | A/16 | 110
Steel Assembly | RIGID_FRAME | 8.4 | +9.970 | +11.215 | E-F/2(09)> | A/13 | 50
Steel Assembly | RIGID_FRAME | 8.4 | +9.970 | +11.215 | C-D/2(09)> | A/13 | 50
Steel Assembly | RIGID_FRAME | 2.7 | +9.950 | +10.069 | C-D/2(09)> | A/12 | 118.898
Steel Assembly | RIGID_FRAME | 2.7 | +9.950 | +10.069 | E-F/2(09)> | A/12 | 118.898
Steel Assembly | RIGID_FRAME | 65.1 | +11.299 | +11.514 | C-E/2(09)> | SZ/8 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +11.148 | +11.363 | C-E/2(09)> | SZ/8 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +10.998 | +11.213 | C-E/2(09)> | SZ/8 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +10.847 | +11.063 | C-E/2(09)> | SZ/8 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +10.697 | +10.912 | C-E/2(09)> | SZ/8 | 137.5
Steel Assembly | RIGID_FRAME | 51.8 | +11.302 | +11.517 | C-F/2(09)> | SZ/9 | 138
Steel Assembly | RIGID_FRAME | 51.8 | +11.151 | +11.367 | C-F/2(09)> | SZ/9 | 138
Steel Assembly | RIGID_FRAME | 51.8 | +11.001 | +11.216 | C-F/2(09)> | SZ/9 | 138
Steel Assembly | RIGID_FRAME | 51.8 | +10.851 | +11.066 | C-F/2(09)> | SZ/9 | 138
Steel Assembly | RIGID_FRAME | 51.8 | +10.700 | +10.916 | C-F/2(09)> | SZ/9 | 138
Steel Assembly | RIGID_FRAME | 65.1 | +11.299 | +11.514 | D-F/2(09)> | SZ/7 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +11.148 | +11.363 | D-F/2(09)> | SZ/7 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +10.998 | +11.213 | D-F/2(09)> | SZ/7 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +10.847 | +11.063 | D-F/2(09)> | SZ/7 | 137.5
Steel Assembly | RIGID_FRAME | 65.1 | +10.697 | +10.912 | D-F/2(09)> | SZ/7 | 137.5
Steel Assembly | RIGID_FRAME | 58.3 | +10.554 | +10.764 | E-F/2(09)> | SZ/5 | 83.0598
Steel Assembly | RIGID_FRAME | 57.9 | +10.554 | +10.764 | D-E/2(09)> | SZ/4 | 83.0598
Steel Assembly | RIGID_FRAME | 58.3 | +10.554 | +10.764 | C-D/2(09)> | SZ/6 | 83.0598
Steel Assembly | RIGID_FRAME | 58.2 | +11.456 | +11.656 | C-D/2(09)> | SZ/3 | 80
Steel Assembly | RIGID_FRAME | 57.8 | +11.456 | +11.656 | D-E/2(09)> | SZ/1 | 80
Steel Assembly | RIGID_FRAME | 58.2 | +11.456 | +11.656 | E-F/2(09)> | SZ/2 | 80
Betonträger | REINFORCEMENT_UNIT | 233.3 | +10.430 | +12.050 | C/2(09)> | T/7 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 132 | +10.434 | +11.350 | C/2(09)> | T/6 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 420.5 | +11.150 | +11.350 | C/2(09)> | T/5 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 262.1 | +10.430 | +12.250 | C/2(09)> | T/4 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 744.5 | +12.050 | +12.250 | C/2(09)> | T/3 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 2507.8 | +9.980 | +10.430 | F/2(09)> | T/1 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 7251.1 | +9.980 | +10.430 | C-F/2(09)> | T/2 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 2507.8 | +9.980 | +10.430 | C/2(09)> | T/1 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 233.3 | +10.430 | +12.050 | F/2(09)> | T/7 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 132 | +10.434 | +11.350 | F/2(09)> | T/6 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 420.5 | +11.150 | +11.350 | F/2(09)> | T/5 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 262.1 | +10.430 | +12.250 | F/2(09)> | T/4 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 744.5 | +12.050 | +12.250 | F/2(09)> | T/3 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
VASBETON | REINFORCEMENT_UNIT | 14770.8 | +9.450 | +9.950 | C-F/2(09)> | VB/1 | 500 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 233.3 | +10.430 | +12.050 | C/2(09) | DUMMY/23 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 132 | +10.434 | +11.350 | C/1(10) | DUMMY/22 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 420.5 | +11.150 | +11.350 | C/1(10)-2(09) | DUMMY/21 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 262.1 | +10.430 | +12.250 | C/1(10)-2(09) | DUMMY/20 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 744.5 | +12.050 | +12.250 | C/1(10)-2(09)> | DUMMY/19 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 2507.8 | +9.980 | +10.430 | F/1(10)-2(09) | DUMMY/24 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 7251.1 | +9.980 | +10.430 | C-F/1(10) | DUMMY/25 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 2507.8 | +9.980 | +10.430 | C/1(10)-2(09) | DUMMY/24 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 233.3 | +10.430 | +12.050 | F/2(09) | DUMMY/23 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 132 | +10.434 | +11.350 | F/1(10) | DUMMY/22 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 420.5 | +11.150 | +11.350 | F/1(10)-2(09) | DUMMY/21 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 262.1 | +10.430 | +12.250 | F/1(10)-2(09) | DUMMY/20 | 200 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Betonträger | REINFORCEMENT_UNIT | 744.5 | +12.050 | +12.250 | F/1(10)-2(09)> | DUMMY/19 | 300 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg
Steel Assembly | RIGID_FRAME | 2.7 | +9.950 | +10.069 | E-F/2(09) | DUMMY/16 | 118.898
Steel Assembly | RIGID_FRAME | 8.4 | +9.970 | +11.215 | E-F/2(09) | DUMMY/34 | 50
Steel Assembly | RIGID_FRAME | 65.9 | +11.287 | +11.387 | E-F/2(09) | DUMMY/30 | 110
Steel Assembly | RIGID_FRAME | 173.7 | +9.950 | +11.631 | F/2(09) | DUMMY/17 | 212.5
Steel Assembly | RIGID_FRAME | 237.2 | +9.950 | +11.631 | E/2(09) | DUMMY/5 | 236.5
Steel Assembly | RIGID_FRAME | 65.9 | +11.287 | +11.387 | D-E/2(09) | DUMMY/27 | 110
Steel Assembly | RIGID_FRAME | 237.2 | +9.950 | +11.631 | D/2(09) | DUMMY/4 | 236.5
Steel Assembly | RIGID_FRAME | 65.9 | +11.287 | +11.387 | C-D/2(09) | DUMMY/30 | 110
Steel Assembly | RIGID_FRAME | 173.7 | +9.950 | +11.631 | C/2(09) | DUMMY/18 | 212.5
Steel Assembly | RIGID_FRAME | 8.4 | +9.970 | +11.215 | C-D/2(09) | DUMMY/34 | 50
Steel Assembly | RIGID_FRAME | 2.7 | +9.950 | +10.069 | C-D/2(09) | DUMMY/16 | 118.898
Steel Assembly | RIGID_FRAME | 128.4 | +7.100 | +10.887 | C/1(10) | DUMMY/15 | 190
Steel Assembly | RIGID_FRAME | 215 | +7.100 | +10.887 | D/1(10) | DUMMY/3 | 246.5
Steel Assembly | RIGID_FRAME | 215 | +7.100 | +10.887 | E/1(10) | DUMMY/2 | 246.5
Steel Assembly | RIGID_FRAME | 128.4 | +7.100 | +10.887 | F/1(10) | DUMMY/14 | 190
Steel Assembly | RIGID_FRAME | 58.3 | +10.554 | +10.764 | E-F/1(10) | DUMMY/10 | 83.0598
Steel Assembly | RIGID_FRAME | 57.9 | +10.554 | +10.764 | D-E/1(10) | DUMMY/9 | 83.0598
Steel Assembly | RIGID_FRAME | 58.3 | +10.554 | +10.764 | C-D/1(10) | DUMMY/11 | 83.0598
Steel Assembly | RIGID_FRAME | 58.2 | +11.456 | +11.656 | C-D/2(09) | DUMMY/8 | 80
Steel Assembly | RIGID_FRAME | 57.8 | +11.456 | +11.656 | D-E/2(09) | DUMMY/6 | 80
Steel Assembly | RIGID_FRAME | 58.2 | +11.456 | +11.656 | E-F/2(09) | DUMMY/7 | 80
2 x Steel Assembly | RIGID_FRAME | 13.5 | +10.472 | +10.907 | D-E/1(10)-2(09) | DUMMY/32 | 70
2 x Steel Assembly | RIGID_FRAME | 13.5 | +10.905 | +11.342 | D-E/1(10)-2(09) | DUMMY/33 | 70.0001
Steel Assembly | RIGID_FRAME | 66.1 | +10.398 | +10.508 | E-F/1(10) | DUMMY/31 | 100
Steel Assembly | RIGID_FRAME | 65.9 | +10.398 | +10.508 | D-E/1(10) | DUMMY/28 | 100
Steel Assembly | RIGID_FRAME | 66.1 | +10.398 | +10.508 | C-D/1(10) | DUMMY/31 | 100
Steel Assembly | RIGID_FRAME | 66.9 | +10.841 | +10.952 | E-F/1(10)-2(09) | DUMMY/29 | 100
Steel Assembly | RIGID_FRAME | 66.1 | +10.841 | +10.952 | D-E/1(10)-2(09) | DUMMY/26 | 100
Steel Assembly | RIGID_FRAME | 66.9 | +10.841 | +10.952 | C-D/1(10)-2(09) | DUMMY/29 | 100
Steel Assembly | RIGID_FRAME | 59.3 | +11.299 | +11.514 | C-E/1(10)-2(09) | DUMMY/13 | 137.5
Steel Assembly | RIGID_FRAME | 59.3 | +11.148 | +11.363 | C-E/1(10)-2(09) | DUMMY/13 | 137.5
Steel Assembly | RIGID_FRAME | 59.3 | +10.998 | +11.213 | C-E/1(10)-2(09) | DUMMY/13 | 137.5
Steel Assembly | RIGID_FRAME | 59.3 | +10.847 | +11.063 | C-E/1(10)-2(09) | DUMMY/13 | 137.5
Steel Assembly | RIGID_FRAME | 51.2 | +10.851 | +11.066 | C-F/1(10)-2(09) | DUMMY/35 | 138
Steel Assembly | RIGID_FRAME | 51.2 | +11.001 | +11.216 | C-F/1(10)-2(09) | DUMMY/35 | 138
Steel Assembly | RIGID_FRAME | 51.2 | +11.151 | +11.367 | C-F/1(10)-2(09) | DUMMY/35 | 138
Steel Assembly | RIGID_FRAME | 51.2 | +11.302 | +11.517 | C-F/1(10)-2(09) | DUMMY/35 | 138
Steel Assembly | RIGID_FRAME | 59.3 | +11.299 | +11.514 | D-F/1(10)-2(09) | DUMMY/12 | 137.5
Steel Assembly | RIGID_FRAME | 59.3 | +11.148 | +11.363 | D-F/1(10)-2(09) | DUMMY/12 | 137.5
Steel Assembly | RIGID_FRAME | 59.3 | +10.998 | +11.213 | D-F/1(10)-2(09) | DUMMY/12 | 137.5
Steel Assembly | RIGID_FRAME | 59.3 | +10.847 | +11.063 | D-F/1(10)-2(09) | DUMMY/12 | 137.5
Steel Assembly | RIGID_FRAME | 59.3 | +10.697 | +10.912 | C-E/1(10)-2(09) | DUMMY/13 | 137.5
Steel Assembly | RIGID_FRAME | 51.2 | +10.700 | +10.916 | C-F/1(10)-2(09) | DUMMY/35 | 138
Steel Assembly | RIGID_FRAME | 59.3 | +10.697 | +10.912 | D-F/1(10)-2(09) | DUMMY/12 | 137.5
VASBETON | REINFORCEMENT_UNIT | 14770.8 | +9.450 | +9.950 | C-F/2(09) | DUMMY/1 | 500 | Tekla Assembly - Cast unit type: Precast; Cast unit rebar weight: 0 kg

# IfcFastener (703)
Tekla Weld Common - Volume: 0 m3; Electrode coefficent: 0; Electrode strength: 0; Weld number: 0; Assembly type: Workshop; Intermittent type: Continuous
Tekla Weld Above Line - Increment count1: 0; Pitch1: 0; Length1: 0 mm; Root opening1: 0 mm; Weld angle1: 0; Effective throat1: 0 mm; Type1: W10
Tekla Weld Below Line - Cross section area2: 0 m2; Increment count2: 0; Pitch2: 0; Length2: 0 mm; Root face thicness2: 0 mm; Root opening2: 0 mm; Weld angle2: 0; Effective throat2: 0 mm
Name | Length (mm) = Actual length1 (mm) | Edge/Around | Cross section area1 (m2) | Root face thickness1 (mm) | Size1 (mm) | Actual length2 (mm) | Size2 (mm)
4 x Weld | 100 | Edge | 0.00001 | 0 | 3 | 100 | 3 | Tekla Weld Below Line - Type2: W10
4 x Weld | 100 | Edge | 0 | 0 | 3 | 100 | 3 | Tekla Weld Below Line - Type2: W10
24 x Weld | 178 | Around | 0.00001 | 0 | 3 | 0 | 0
54 x Weld | 100 | Around | 0.00002 | 0 | 4 | 0 | 0
Weld | 1157.3 | Around | 0.00002 | 0 | 4 | 0 | 0
2 x Weld | 285.5 | Around | 0.00002 | 0 | 4 | 0 | 0
Weld | 1138.3 | Around | 0.00002 | 0 | 4 | 0 | 0
2 x Weld | 289.1 | Around | 0.00002 | 0 | 4 | 0 | 0
Weld | 1113.3 | Around | 0.00002 | 0 | 4 | 0 | 0
2 x Weld | 290.4 | Around | 0.00002 | 0 | 4 | 0 | 0
24 x Weld | 378 | Around | 0.00001 | 0 | 3 | 0 | 0
4 x Weld | 319.6 | Around | 0 | 0 | 4 | 0 | 0
8 x Weld | 79.2 | Around | 0 | 0 | 4 | 0 | 0
7 x Weld | 394.4 | Around | 0 | 0 | 4 | 0 | 0
18 x Weld | 98.6 | Around | 0 | 0 | 4 | 0 | 0
Weld | 396.8 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 99.8 | Around | 0 | 0 | 4 | 0 | 0
Weld | 341.1 | Around | 0.00002 | 0 | 4 | 0 | 0
4 x Weld | 284 | Around | 0 | 0 | 4 | 0 | 0
36 x Weld | 180 | Around | 0.00001 | 0 | 3 | 0 | 0
6 x Weld | 43 | Around | 0.00001 | 0 | 3 | 0 | 0
6 x Weld | 152 | Around | 0 | 0 | 3 | 0 | 0
6 x Weld | 101 | Around | 0 | 0 | 4 | 0 | 0
8 x Weld | 99.5 | Around | 0 | 0 | 4 | 0 | 0
9 x Weld | 137 | Around | 0.00001 | 0 | 3 | 0 | 0
9 x Weld | 86 | Around | 0.00001 | 0 | 3 | 0 | 0
10 x Weld | 80 | Around | 0.00001 | 0 | 3 | 0 | 0
2 x Weld | 18 | Around | 0.00001 | 0 | 3 | 0 | 0
8 x Weld | 60 | Around | 0.00002 | 0 | 4 | 0 | 0
2 x Weld | 36 | Around | 0.00001 | 0 | 3 | 0 | 0
2 x Weld | 62 | Around | 0.00001 | 0 | 3 | 0 | 0
2 x Weld | 348.2 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 217.9 | Around | 0 | 0 | 4 | 0 | 0
4 x Weld | 60.5 | Edge | 0.00001 | 0 | 3 | 60.5 | 3 | Tekla Weld Below Line - Type2: W10
16 x Weld | 5 | Edge | 0.00001 | 0 | 3 | 5 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 150 | Edge | 0.00001 | 0 | 3 | 150 | 3 | Tekla Weld Below Line - Type2: W10
2 x Weld | 59.8 | Edge | 0.00001 | 0 | 3 | 60.5 | 3 | Tekla Weld Below Line - Type2: W10
2 x Weld | 59.8 | Edge | 0.00001 | 0 | 3 | 59.8 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 190 | Edge | 0.00001 | 0 | 3 | 190 | 3 | Tekla Weld Below Line - Type2: W10
4 x Weld | 4 | Edge | 0.00001 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
4 x Weld | 183 | Edge | 0.00001 | 0 | 3 | 183 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 100 | Edge | 0.00004 | 0 | 6 | 94.4 | 6 | Tekla Weld Below Line - Type2: W10
4 x Weld | 220.4 | Edge | 0.00001 | 0 | 3 | 220.4 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 120 | Edge | 0.00004 | 0 | 6 | 113.8 | 6 | Tekla Weld Below Line - Type2: W10
30 x Weld | 240 | Around | 0.00004 | 0 | 5 | 0 | 0
2 x Weld | 183 | Edge | 0.00002 | 0 | 4 | 183 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 100 | Edge | 0.00001 | 0 | 4 | 94.4 | 4 | Tekla Weld Below Line - Type2: W10
8 x Weld | 45.5 | Edge | 0.00002 | 2 | 4 | 45.5 | 4 | Tekla Weld Below Line - Type2: W10
8 x Weld | 74 | Edge | 0.00002 | 2 | 4 | 74 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 1209.7 | Edge | 0.00001 | 0 | 3 | 1190.3 | 3 | Tekla Weld Below Line - Type2: W10
2 x Weld | 183 | Edge | 0.00004 | 0 | 5 | 183 | 5 | Tekla Weld Below Line - Type2: W10
2 x Weld | 100 | Edge | 0.00004 | 0 | 5 | 94.4 | 5 | Tekla Weld Below Line - Type2: W10
2 x Weld | 47.2 | Edge | 0.00002 | 0 | 5 | 100 | 5 | Tekla Weld Below Line - Type2: W10
8 x Weld | 31.2 | Edge | 0.00002 | 2 | 4 | 31.2 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 10 | Edge | 0.00001 | 2 | 4 | 10 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 221.9 | Edge | 0.00004 | 0 | 5 | 221.9 | 5 | Tekla Weld Below Line - Type2: W10
2 x Weld | 120 | Edge | 0.00002 | 0 | 5 | 113.8 | 5 | Tekla Weld Below Line - Type2: W10
2 x Weld | 56.9 | Edge | 0.00004 | 0 | 5 | 120 | 5 | Tekla Weld Below Line - Type2: W10
8 x Weld | 44.8 | Edge | 0.00002 | 2 | 4 | 44.8 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 1186.2 | Edge | 0.00001 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
4 x Weld | 190 | Edge | 0.00001 | 0 | 3 | 191.4 | 3 | Tekla Weld Below Line - Type2: W10
4 x Weld | 1209.5 | Edge | 0.00001 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
2 x Weld | 120 | Edge | 0.00004 | 0 | 5 | 113.8 | 5 | Tekla Weld Below Line - Type2: W10
2 x Weld | 56.9 | Edge | 0.00002 | 0 | 5 | 120 | 5 | Tekla Weld Below Line - Type2: W10
8 x Weld | 78.8 | Edge | 0.00002 | 2 | 4 | 78.8 | 4 | Tekla Weld Below Line - Type2: W10
4 x Weld | 134 | Edge | 0.00002 | 2 | 4 | 134 | 4 | Tekla Weld Below Line - Type2: W10
2 x Weld | 680.8 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 157.3 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 1141.9 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 764.8 | Around | 0.00004 | 0 | 5 | 0 | 0
2 x Weld | 1103 | Around | 0.00004 | 0 | 5 | 0 | 0
2 x Weld | 435 | Around | 0.00004 | 0 | 5 | 0 | 0
2 x Weld | 683 | Around | 0.00004 | 0 | 5 | 0 | 0
2 x Weld | 233.1 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 166.1 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 153 | Around | 0 | 0 | 3 | 0 | 0
4 x Weld | 190.4 | Around | 0 | 0 | 3 | 0 | 0
6 x Weld | 68 | Around | 0 | 0 | 3 | 0 | 0
11 x Weld | 100 | Around | 0 | 0 | 4 | 0 | 0
4 x Weld | 5 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 178.1 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
4 x Weld | 150 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 187.3 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
2 x Weld | 1186.2 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
Weld | 1209.5 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
4 x Weld | 191.4 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 4 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
6 x Weld | 1202.9 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
Weld | 1210.5 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
2 x Weld | 1187.2 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
6 x Weld | 80 | Around | 0.00002 | 0 | 4 | 0 | 0
2 x Weld | 103.5 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 109.5 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 170 | Around | 0.00002 | 0 | 4 | 0 | 0
2 x Weld | 90.3 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 93.1 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 155 | Around | 0 | 0 | 4 | 0 | 0
4 x Weld | 134 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 171.3 | Around | 0 | 0 | 4 | 0 | 0
4 x Weld | 1209.7 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 50 | Around | 0 | 0 | 4 | 0 | 0
4 x Weld | 85 | Around | 0 | 0 | 4 | 0 | 0
2 x Weld | 183 | Around | 0 | 0 | 5 | 0 | 0
2 x Weld | 170 | Around | 0 | 0 | 5 | 0 | 0
4 x Weld | 183 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 100 | Edge | 0 | 0 | 6 | 0 | 6 | Tekla Weld Below Line - Type2: W10
4 x Weld | 220.4 | Edge | 0 | 0 | 3 | 0 | 3 | Tekla Weld Below Line - Type2: W10
8 x Weld | 120 | Edge | 0 | 0 | 6 | 0 | 6 | Tekla Weld Below Line - Type2: W10
4 x Weld | 98 | Around | 0 | 0 | 5 | 0 | 0
4 x Weld | 120 | Edge | 0 | 2 | 5 | 0 | 5 | Tekla Weld Below Line - Type2: W10
4 x Weld | 56.9 | Edge | 0 | 2 | 5 | 0 | 5 | Tekla Weld Below Line - Type2: W10
4 x Weld | 221.9 | Edge | 0 | 2 | 5 | 0 | 5 | Tekla Weld Below Line - Type2: W10
8 x Weld | 44.8 | Edge | 0 | 2 | 4 | 0 | 4 | Tekla Weld Below Line - Type2: W10
